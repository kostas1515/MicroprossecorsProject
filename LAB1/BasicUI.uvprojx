# Keil uVision project BasicUI.uvprojx, settings and files
target KL25Z Flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.0.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: BasicUI
  c flags: Optim=1
  c include: include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --libpath "C:\Keil\ARM\ARMCC\lib"
  group Startup
    ./: startup_MKL25Z4.s system_MKL25Z4.c
  group source
    ./src/: main.c
  group include
    ./include/: gpio_defs.h lcd_4bit.h switches.h
software components: CMSIS:CORE 4.1.0
